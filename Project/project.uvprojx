# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CODE;..\HARDWARD_LIB\inc;..\STM32F10x_LIB\inc;..\STM32F10x_SoftWare_LIB\inc;..\system\delay;..\system\key;..\system\sys;..\system\usart;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c Enable_sys_file.h hardWaveLIB.h
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
    ../system/key/: key.c
  group CODE
    ../CODE/: startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c core_cm3.c
  group HARDWARD_LIB
    ../HARDWARD_LIB/src/: IIC.c mpu6050.c hmc5883l.c LCD_device.c BMP085.c ULtrasonic.c OLED.c NRF2401L.c inv_mpu.c inv_mpu_dmp_motion_driver.c
  group STM32F10x_LIB
    ../STM32F10x_LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32F10x_SoftWare_LIB
    ../STM32F10x_SoftWare_LIB/src/: ADC.C capture.c CODEr.c DMA.c EXIT.c interrupt.c PWM.c SPI.c TIM.c
